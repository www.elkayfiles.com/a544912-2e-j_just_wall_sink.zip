Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-11-14T20:16:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 14 20:16:48 2023 * Host: ZILFY3SGS3 * Database: C:\Users\ENIDAM~1\AppData\Local\Temp\d574962d-15c6-4565-951d-93ce48331ef8\9544c6ef-e240-4e0b-ace6-08277b5ccf65\ifc * Database version: 5507 * Database creation date: Tue Nov 14 20:16:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 14 20:16:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 14 20:16:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: A544912-2E-J:A544912S-2E-J, A544912-2E-J:A544912S-2E-J:811719
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: A544912S-2E-J
Pset_DistributionFlowElementCommon - Reference: A544912S-2E-J; sets with these values: 2
